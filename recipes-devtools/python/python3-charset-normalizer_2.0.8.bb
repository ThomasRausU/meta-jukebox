SUMMARY = "A library that helps you read text from an unknown charset encoding."
HOMEPAGE = "https://pypi.org/project/charset-normalizer/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0974a390827087287db39928f7c524b5"

SRC_URI[sha256sum] = "735e240d9a8506778cd7a453d97e817e536bb1fc29f4f6961ce297b9c7a917b0"

PYPI_PACKAGE = "charset-normalizer"
inherit pypi setuptools3
