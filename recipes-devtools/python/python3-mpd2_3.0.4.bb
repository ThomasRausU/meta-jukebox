SUMMARY = "python-mpd2 is a Python library which provides a client interface for the Music Player Daemon."
HOMEPAGE = "https://pypi.org/project/python-mpd2/"
LICENSE = "LGPLv3"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI[sha256sum] = "7a67834e22d97e7cd77f8951c8baf87c149285c67d67d73550ce034302561ae5"

PYPI_PACKAGE = "python-mpd2"
inherit pypi setuptools3
