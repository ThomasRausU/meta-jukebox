SUMMARY = "This module provides RFC 3986 compliant functions for parsing, classifying and composing URIs and URI references, largely replacing the Python Standard Library’s urllib.parse module."
HOMEPAGE = "https://pypi.org/project/uritools/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=27f7518eb6f7dc686d0f953b2f28dae5"

SRC_URI[sha256sum] = "a3e9c794d44fdbd54642dcb7d6ef3ba9866d953eb34f65aeca3754b7ad5c1ea0"

PYPI_PACKAGE = "uritools"
inherit pypi setuptools3
