SUMMARY = "Small and dependency free Python package to infer file type and MIME type checking the magic numbers signature of a file or buffer."
HOMEPAGE = "https://pypi.org/project/filetype/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=cc0e8af5f14a75ce53b7b9db0f4bd91e"

SRC_URI[sha256sum] = "77df14879b73fd9711b8bd4f465dadf2ecdafff0eac3b22c0bdb0ccba68db316"

PYPI_PACKAGE = "filetype"
inherit pypi setuptools3
