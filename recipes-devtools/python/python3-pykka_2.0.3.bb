SUMMARY = "Pykka is a Python implementation of the actor model"
HOMEPAGE = "https://www.pykka.org/"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[sha256sum] = "4b9d2363365b3455a0204bf163f09bd351d24b938c618c79d975a9510e128e95"

PYPI_PACKAGE = "Pykka"
inherit pypi setuptools3
