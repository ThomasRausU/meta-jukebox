SUMMARY = "Python audio data toolkit (ID3 and MP3)"
HOMEPAGE = "https://pypi.org/project/eyed3/"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://LICENSE;md5=8006d9c814277c1bfc4ca22af94b59ee"

SRC_URI[sha256sum] = "4b5064ec0fb3999294cca0020d4a27ffe4f29149e8292fdf7b2de9b9cabb7518"

PYPI_PACKAGE = "eyeD3"
inherit pypi setuptools3
