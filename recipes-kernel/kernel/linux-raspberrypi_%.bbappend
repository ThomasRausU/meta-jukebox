FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://wm8960.cfg \
			file://general.cfg"
